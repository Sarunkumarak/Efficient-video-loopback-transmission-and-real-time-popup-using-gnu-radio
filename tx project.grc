options:
  parameters:
    author: ARUNKUMAR S
    generate_options: qt_gui
    id: tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/arunkumar-ak/Videos/ajith1.mp4
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/arunkumar-ak/Videos/ajith.mp4
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_char_1
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.3'
    samples_per_symbol: '2'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import subprocess\nimport threading\nimport time\nimport os\nfrom gnuradio import gr\nimport numpy as np\n\nclass blk(gr.sync_block):  # You can also use basic_block\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name=\"Play Video\",\n            in_sig=[np.float32],   # Match float input\n            out_sig=[np.float32])  # Dummy output\n        self.video_played = False\n\n    def start(self):\n        if not self.video_played:\n            self.video_played = True\n            threading.Thread(target=self.play_video, daemon=True).start()\n        return super().start()\n\n    def play_video(self):\n        try:\n            video_path = \"/home/arunkumar-ak/Videos/ajith.mp4\"\n            output_path = \"/home/arunkumar-ak/Videos/ajith1.mp4\"\n\n            if os.path.exists(video_path):\n                subprocess.run([\"chmod\", \"+r\", video_path], check=True)\n                subprocess.run([\"chmod\", \"+w\", \"/home/arunkumar-ak/Videos/\"], check=True)\n\n                subprocess.run([\n                    \"ffmpeg\", \"-y\", \"-loglevel\", \"error\",\n                    \"-i\", video_path,\n                    \"-c:v\", \"libx264\", \"-preset\", \"slow\",\n                    \"-c:a\", \"aac\", \"-strict\", \"-2\",\n                    output_path\n                ], check=True)\n\n                time.sleep(1)\n\n                subprocess.run([\n                    \"ffplay\", \"-autoexit\", output_path\n                ], check=True)\n            else:\n                print(\"Video file not found!\")\n        except subprocess.CalledProcessError as e:\n            print(\"Error during video play:\", e)\n\n    def work(self, input_items, output_items):\n        # Just forward the input to output\n        output_items[0][:] = input_items[0]\n        return len(output_items[0])\n\n\n\n\n\n\n\n\n\n"
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: '"127.0.0.1"'
    header: '0'
    payloadsize: '1472'
    port: '52001'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '5'
    ipv6: 'False'
    notify_missed: 'False'
    port: '52001'
    src_zeros: 'False'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://127.0.0.1:5555"'
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: '"tcp://127.0.0.1:5555"'
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [blocks_char_to_float_0, '0', blocks_float_to_char_1, '0']
- [blocks_complex_to_float_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_float_0, '1', blocks_float_to_complex_0, '1']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_float_to_char_0, '0', digital_gmsk_mod_0, '0']
- [blocks_float_to_char_1, '0', blocks_file_sink_0, '0']
- [blocks_float_to_complex_0, '0', digital_gmsk_demod_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_char_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_gmsk_demod_0, '0', blocks_char_to_float_0, '0']
- [digital_gmsk_mod_0, '0', network_udp_sink_0, '0']
- [epy_block_0, '0', blocks_null_sink_0, '0']
- [network_udp_source_0, '0', zeromq_pub_sink_0, '0']
- [zeromq_sub_source_0, '0', blocks_complex_to_float_0, '0']
- [zeromq_sub_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
